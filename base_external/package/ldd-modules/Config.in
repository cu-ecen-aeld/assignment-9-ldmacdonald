## base_external/package/ldd-modules/Config.in
```kconfig
config BR2_PACKAGE_LDD_MODULES
	bool "ldd-modules"
	help
	  Includes ldd modules in the kernel image.
```
